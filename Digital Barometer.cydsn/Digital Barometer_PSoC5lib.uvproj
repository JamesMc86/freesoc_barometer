# Keil uVision project Digital Barometer_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Digital Barometer_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h SDA_aliases.h SDA.c SDA.h SCL_aliases.h SCL.c SCL.h LED_1_aliases.h LED_1.c LED_1.h LED_Out.c LED_Out.h LED_2_aliases.h LED_2.c LED_2.h I2C.c I2C.h I2C_BOOT.c I2C_INT.c I2C_PM.c I2C_SLAVE.c I2C_MASTER.c I2C_PVT.h I2C_IntClock.c I2C_IntClock.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Digital Barometer_PSoC5lib (library)
